<?xml version="1.0" encoding="UTF-8" standalone="no" ?>
<ProjectWorkspace xmlns:xsi="http://www.w3.org/2001/XMLSchema-instance" xsi:noNamespaceSchemaLocation="project_mpw.xsd">

  <SchemaVersion>1.0</SchemaVersion>

  <Header>### uVision Project, (C) Keil Software</Header>

  <WorkspaceName>WorkSpace</WorkspaceName>

  <project>
    <PathAndName>.\00-STM32Fxxx_PROYECT\project.uvprojx</PathAndName>
    <NodeIsActive>1</NodeIsActive>
    <NodeIsExpanded>1</NodeIsExpanded>
  </project>

  <project>
    <PathAndName>.\04-STM32Fxxx_EXTI\project.uvprojx</PathAndName>
  </project>

  <project>
    <PathAndName>.\07-STM32Fxxx_USART\project.uvprojx</PathAndName>
  </project>

  <project>
    <PathAndName>.\07-STM32Fxxx_USART_STRING\project.uvprojx</PathAndName>
  </project>

  <project>
    <PathAndName>.\13-STM32Fxxx_BUTTON\project.uvprojx</PathAndName>
  </project>

</ProjectWorkspace>
